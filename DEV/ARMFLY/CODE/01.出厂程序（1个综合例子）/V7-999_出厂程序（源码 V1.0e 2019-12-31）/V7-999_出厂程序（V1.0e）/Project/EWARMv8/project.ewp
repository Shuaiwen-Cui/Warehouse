# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; USE_USBH_HS; USE_USBD_FS
  ICCARM.CCDiagSuppress: Pe301,Pa182
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Libraries\STM32H7xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\User\fonts; ..\..\User\images; ..\..\User\app\inc; ..\..\Libraries\STM32_USB_Host_Library\Core\Inc; ..\..\Libraries\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\User\usbh_mass_storage; ..\..\Libraries\FatFs\src; ..\..\Libraries\FatFs\src\drivers; ..\..\Libraries\STM32_USB_Device_Library\Core\Inc; ..\..\Libraries\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\User\usbd_mass_storage; ..\..\Libraries\LwIP\src\include; ..\..\Libraries\LwIP\src\apps; ..\..\Libraries\LwIP\system; ..\..\Libraries\LwIP\phy_drv; ..\..\User\http_lwip; ..\..\Libraries\uIP\uip; ..\..\Libraries\uIP\dm9000; ..\..\User\http_uip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: v7_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../../User/app/src/: bmp_file.c can_network.c form_ad7606.c form_ad7705_.c form_ad9833.c form_ads1256.c form_audio_rec.c form_camera.c form_can.c form_dac8501.c form_dac8562.c form_dso.c form_fm_radio.c form_gprs_t.c form_gps.c form_hard_test.c form_http_server.c form_main_menu.c form_mems.c form_mp3_player.c form_oled_.c form_reserve.c form_rs485.c form_touch.c form_usbd_msc.c form_wifi.c main.c num_pad.c param.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_msg.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_camera.c bsp_can.c bsp_cpu_adc.c bsp_cpu_dac.c bsp_cpu_rtc.c bsp_dht11.c bsp_ds18b20.c bsp_fmc_ad7606.c bsp_fmc_io.c bsp_fmc_nand_flash.c bsp_fmc_oled.c bsp_fmc_sdram.c bsp_i2c_bh1750.c bsp_i2c_bmp085.c bsp_i2c_eeprom_24xx.c bsp_i2c_gpio.c bsp_i2c_hmc5883l.c bsp_i2c_mpu6050.c bsp_i2c_si4730.c bsp_i2c_wm8978.c bsp_ir_decode.c bsp_key.c bsp_led.c bsp_ps2.c bsp_qspi_w25q256.c bsp_rs485_led.c bsp_sdio_sd.c bsp_spi_ad9833.c bsp_spi_ads1256.c bsp_spi_bus.c bsp_spi_dac8501.c bsp_spi_dac8562.c bsp_spi_flash.c bsp_spi_tm7705.c bsp_spi_vs1053b.c bsp_tft_h7.c bsp_tft_lcd.c bsp_tim_pwm.c bsp_timer.c bsp_ts_ft5x06.c bsp_ts_gt811.c bsp_ts_gt911.c bsp_ts_stmpe811.c bsp_ts_touch.c bsp_uart_esp8266.c bsp_uart_fifo.c bsp_uart_gps.c bsp_uart_sim800.c bsp_user_lib.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
  group FatFS
    ../../Libraries/FatFs/src/option/: cc936.c syscall.c
    ../../Libraries/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../Libraries/FatFs/src/drivers/: nand_diskio.c sd_diskio_dma.c sdram_diskio.c usbh_diskio.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group Images
    ../../User/images/: ADC.c Camera.c ChiLun.c chujiao.c FM.c GPS.c hwinfo.c images.h LCD.c MP3.c Phone.c radio.c Recorder.c USBDisk.c web.c Wireless.c
  group LwIP
    ../../Libraries/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Libraries/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Libraries/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Libraries/LwIP/src/netif/: ethernet.c
  group LwIP-HTTP
    ../../User/http_lwip/: app_ethernet.c ethernetif.c httpd_cgi_ssi.c lwipopts.h
    ../../Libraries/LwIP/src/apps/httpd/: fs.c httpd.c
  group LwIP-PhyDrv
    ../../Libraries/LwIP/phy_drv/: dm9162.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group uIP
    ../../Libraries/uIP/lib/: memb.c
    ../../Libraries/uIP/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group uIP-DM9000
    ../../Libraries/uIP/dm9000/: clock-arch.c dm9k_uip.c tapdev.c
  group uIP-HTTP
    ../../User/http_uip/: http-strings.c httpd-cgi.c httpd-fs.c httpd_u.c
  group USB_Device_Library
    ../../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Libraries/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Host_Library
    ../../Libraries/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Libraries/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group USBD MassStorage
    ../../User/usbd_mass_storage/: usbd_conf.c usbd_desc.c usbd_it.c usbd_storage.c usbd_usr.c
  group USBH MassStorage
    ../../User/usbh_mass_storage/: usbh_conf.c usbh_it.c usbh_usr.c
